v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 120 -80 140 -80 {}
L 4 30 -80 50 -80 {}
L 4 50 -120 50 -60 {}
L 4 50 -60 50 -40 {}
L 4 60 -120 100 -80 {}
L 4 60 -40 100 -80 {}
L 4 50 -30 60 -40 {}
L 4 50 -40 50 -30 {}
L 4 50 -130 50 -120 {}
L 4 50 -130 60 -120 {}
L 7 70 -140 70 -110 {}
L 7 70 -50 70 -20 {}
B 5 67.5 -142.5 72.5 -137.5 {name=VDD dir=inout}
B 5 67.5 -22.5 72.5 -17.5 {name=VSS dir=inout}
B 5 137.5 -82.5 142.5 -77.5 {name=INV_OUT sig_type=std_logic dir=out}
B 5 27.5 -82.5 32.5 -77.5 {name=INV_IN sig_type=std_logic dir=in}
A 4 110 -80 10 270 360 {}
T {@symname} 95 -106 0 0 0.3 0.3 {}
T {@name} 55 -82 0 0 0.2 0.2 {}
T {VDD} 95 -144 0 1 0.2 0.2 {}
T {VSS} 95 -24 0 1 0.2 0.2 {}
T {INV_OUT} 145 -74 0 1 0.2 0.2 {}
T {INV_IN} 25 -74 0 0 0.2 0.2 {}
